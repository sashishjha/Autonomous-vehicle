# Keil uVision project RTES_Project.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x00800000,0x00020000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: RTES_Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x800000 size 0x20000
  group Source Group 1
    ./: main.c gpio.h gpio.c ledbtn.h ledbtn.c microbit.h nrf52833.h nrf52833_bitfields.h display.c display.h bsp.h motor.h motor.c pins.h servo.h servo.c ultrasonic.h ultrasonic.c radio.h radio.c uart.h uart.c printf.c printf.h
software components: CMSIS:CORE 6.2.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.2.0, RTOS:Config 11.2.0, RTOS:Core 11.2.0, RTOS:Event Groups 11.2.0, RTOS:Heap 11.2.0, RTOS:Message Buffer 11.2.0, RTOS:Timers 11.2.0, Device:Startup 8.44.1
